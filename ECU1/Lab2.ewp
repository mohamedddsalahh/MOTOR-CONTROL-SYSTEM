# IAR project Lab2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\Senior2 Fall\Senior II\Fall 23\MCT422 Automotive Embedded Networking\Major Submission\CMSIS_5-5.9.0\CMSIS_5-5.9.0\CMSIS\Core\Include; D:\Senior2 Fall\Senior II\Fall 23\MCT422 Automotive Embedded Networking\Major Submission\CMSIS_5-5.9.0\CMSIS_5-5.9.0\CMSIS\Core_A\Include; D:\Senior2 Fall\Senior II\Fall 23\MCT422 Automotive Embedded Networking\Major Submission\CMSIS_5-5.9.0\CMSIS_5-5.9.0\Device\ARM\ARMCM4\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lab2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: adc.c adc.h ARMCM4.h bitwise_operation.h CAN.c CAN.h ECU1.c ECU1.h ECU1_PBConfig.c FlashM.c FlashM.h gpio.c gpio.h GPTM.c GPTM.h LED.c LED.h main.c MY_RTOS_FIFO.c MY_RTOS_FIFO.h Schedular.c Schedular.h Schedular_Cfg.c Schedular_Cfg.h SSI.c SSI.h startup_ARMCM4.c switch.c switch.h system_ARMCM4.c system_ARMCM4.h systick.c systick.h tm4c123gh6pm.h types.h uart.c uart.h
